# IAR project My_CAN.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F205RB ST STM32F205RB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: STM32F2XX_LIB; CMSIS
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: My_CAN.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group (top)
    ./: main.c stm32f2xx_it.c
  group CMSIS
    CMSIS/: system_stm32f2xx.c
  group EWARM
    EWARM/: startup_stm32f2xx.s
  group STM32F2XX_LIB
    STM32F2XX_LIB/: misc.c stm32f2xx_adc.c stm32f2xx_can.c stm32f2xx_dma.c stm32f2xx_gpio.c stm32f2xx_rcc.c stm32f2xx_tim.c
